# Keil uVision project MenuLEDs.uvproj, settings and files
target MiniDK2 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: MenuLEDs
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: __DBG_ITM
  c include: ..\Libraries\CM3\CoreSupport;..\Libraries\CM3\DeviceSupport;..\Libraries\GLCD;..\Libraries\TouchPanel;..\USER;..\Libraries\LPC1700CMSIS_Firmware_Library\include;..\Libraries\LEDs;..\Libraries\SD_FILE;..\Libraries\SERIAL;..\Libraries\SPI;..\Libraries\TCP_CM3;..\Web
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group StartUp
    ../Libraries/CM3/DeviceSupport/: startup_LPC17xx.s system_LPC17xx.c
    ../Libraries/CM3/CoreSupport/: core_cm3.c
  group User
    ../USER/: main.c HTTP_CGI.c
    ./: pantalla_LCD.c uartfifo.c i2c_lpc17xx.c nunchuk.c nunchuk.h pantalla_LCD.h
  group GLCD
    ../Libraries/GLCD/: GLCD.c AsciiLib.c
  group TouchPanel
    ../Libraries/TouchPanel/: TouchPanel.c
  group CMSIS
    ../Libraries/LPC1700CMSIS_Firmware_Library/source/: lpc17xx_gpio.c lpc17xx_pinsel.c lpc17xx_ssp.c lpc17xx_clkpwr.c lpc17xx_libcfg_default.c
  group LEDs
    ../Libraries/LEDs/: leds.c
  group Serial
    ../Libraries/SERIAL/: Serial.c
  group Net_Files
    ../USER/: Net_Config.c Net_Debug.c
    ../Libraries/TCP_CM3/: EMAC_LPC17xx_LAN8720.c TCP_CM3.lib TCPD_CM3.lib
  group Readme
    ../: readme.txt
  group WebData
    ../Web/: Web.inp web.c index.cgi
